PROGRAM MAIN
VAR
	
pub_var1 AT%Q*:BYTE;
sub_var1 AT%I*:BYTE;
END_VAR

;

END_PROGRAM
