PROGRAM MAIN
VAR
	
pub_var2 AT%Q*:BYTE;
sub_var2 AT%I*:BYTE;
END_VAR

END_PROGRAM
